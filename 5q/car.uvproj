# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(11059200)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Config;.\Drivers;.\App
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Config
    ./Config/: board.h config.h
  group App
    ./App/: line.c line.h car.c car.h display.c display.h
  group Drivers
    ./Drivers/: motor.c motor.h oled.c oled.h timebase.c timebase.h ultrasonic.c ultrasonic.h
